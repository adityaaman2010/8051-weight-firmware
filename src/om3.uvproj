# Keil uVision project om3.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82FG5B32 Megawin
  cpu: IRAM(0x00 - 0xFF) XRAM (0x00-0x6FF) IROM(0x000 - 0x7FFF) CLOCK(25000000)
  output: om3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: om3.c macro.h tm1640.c utility.c
